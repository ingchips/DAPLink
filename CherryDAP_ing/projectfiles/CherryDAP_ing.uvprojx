# Keil uVision project CherryDAP_ing.uvprojx, settings and files
target CherryDAP_ing (6240000::V6.24::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.1.0.1
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: CherryDAP_ing +hex
  AfterMake: fromelf.exe --bin -o CherryDAP_ing.bin ./output/CherryDAP_ing.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\src;..\CherryDAP;..\CherryDAP\DAP\Include;..\StartUP\ing916;..\StartUP;..\FWlib;..\BSP;..\cmsis-core;..\Tools;..\CherryUSB;..\CherryUSB\common;..\CherryUSB\core;..\CherryUSB\class\cdc;..\CherryUSB\class\hid;..\CherryUSB\class\msc;..\CherryUSB\port\dwc2;..\CherryUSB\osal;..\CherryUSB\third_party\cherryrb;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\VenusFTO_Validation_common;..\VenusFTO_Validation_common\registers
  library: MicroLIB
  memory RVCT4: ROM 0x200f000 size 0x58000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\CherryDAP_ing.sct
  group APP
    ../src/: main.c platform.c HardFault_Handler.c swd_spi.c
  group StartUP
    ../src/: startup_ARMCM4.s
  group CherryDAP
    ../CherryDAP/: dap_main.c
    ../CherryDAP/DAP/Source/: DAP.c JTAG_DP.c SWO.c UART.c DAP_vendor.c
  group BSP
    ../BSP/: eflash.c
  group FWlib
    ../FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_usb.c
  group CherryUSB
    ../src/: usb_config.h usb_glue_ingchips.c
    ../CherryUSB/port/dwc2/: usb_dc_dwc2.c
    ../CherryUSB/core/: usbd_core.c
    ../CherryUSB/osal/: usb_osal_freertos.c
    ../CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../CherryUSB/class/hid/: usbd_hid.c
    ../CherryUSB/third_party/cherryrb/: chry_ringbuffer.c
  group FreeRTOS
    ../FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
