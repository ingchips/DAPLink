# Keil uVision project ing916__bl.uvprojx, settings and files
target ing916_bl (6240000::V6.24::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.1.0.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x2000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ing916_bl +hex
  AfterMake: fromelf.exe --bin -o ing916_bl.bin ./build/ing916_bl.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\src\FWlib;.\src\StartUP\ing916;.\src;.\src\Tools;.\src\BSP;.\bsp\VenusFTO_Validation_common;.\bsp\VenusFTO_Validation_common\registers;.\CherryUSB\common;.\CherryUSB\core;.\CherryUSB\class\msc;.\CherryUSB;.\daplink\drag-n-drop;.\daplink;.\daplink\settings;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x2002000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --bestdebug --predefine=-DDAPLINK_IF --predefine="-I..\..\..\source\hic_hal\ingchips\ing91682a"
  group FWlib
    ./src/FWlib/: peripheral_dma.c peripheral_gpio.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_uart.c peripheral_pwm.c peripheral_timer.c
  group User
    ./user/: main.c startup_ARMCM4.s sys_init.c msc_vitual.c
  group Bsp
    ./src/BSP/: eflash.c
  group CherryUsb
    ./CherryUSB/class/msc/: usbd_msc.c
    ./CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_ingchips.c
    ./CherryUSB/: usb_config.h
  group drag-n-drop
    ./CherryUSB/core/: usbd_core.c
    ./daplink/drag-n-drop/: file_stream.c flash_decoder.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
software components: CMSIS:CORE 5.6.0
