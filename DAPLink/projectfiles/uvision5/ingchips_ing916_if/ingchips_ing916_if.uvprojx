# Keil uVision project ingchips_ing916_if.uvprojx, settings and files
target ingchips_ing916_if (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.1.0.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x2000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ingchips_ing916_if
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: DAPLINK_VERSION=259, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DRAG_N_DROP_SUPPORT, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, OS_TICK_FREQ=100, INTERFACE_ING91682A, DAPLINK_HIC_ID=0x97969922, OS_CLOCK=96000000, __DAPLINK, USE_STDPERIPH_DRIVER, HID_ENDPOINT, BULK_ENDPOINT, USE_LEGACY_CMSIS_RTOS, OS_TICK=10000
  c misc: --gnu --asm --interleave -g
  c include: ..\..\..\source\usb; ..\..\..\source\daplink\cmsis-dap; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\usb2uart; ..\..\..\source\daplink\settings; ..\..\..\source\daplink; ..\..\..\source\daplink\interface; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\hic_hal\cmsis-driver; ..\..\..\source\target; ..\..\..\source\hic_hal\ingchips\ing91682a; ..\..\..\source\hic_hal\ingchips\ing91682a\src\Tools; ..\..\..\source\hic_hal\ingchips\ing91682a\src\BSP; ..\..\..\source\hic_hal\ingchips\ing91682a\src\FWlib; ..\..\..\source\hic_hal\ingchips\ing91682a\src\StartUP; ..\..\..\source\hic_hal\ingchips\ing91682a\src\StartUP\ing916; ..\..\..\source\hic_hal\ingchips\ing91682a\VenusFTO_Validation_common; ..\..\..\source\hic_hal\ingchips\ing91682a\VenusFTO_Validation_common\registers; ..\..\..\source\rtos
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=259,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DOS_TICK_FREQ=100,-DINTERFACE_ING91682A,-DDAPLINK_HIC_ID=0x97969922,-DOS_CLOCK=96000000,-D__DAPLINK,-DUSE_STDPERIPH_DRIVER,-DHID_ENDPOINT,-DBULK_ENDPOINT,-DUSE_LEGACY_CMSIS_RTOS,-DOS_TICK=10000 -g
  library: MicroLIB
  memory RVCT4: ROM 0x2004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --bestdebug --predefine=-DDAPLINK_IF --predefine="-I..\..\..\source\hic_hal\ingchips\ing91682a"
  group board
    ../../../source/board/: ing91682a.c
  group cmsis-dap
    ../../../source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_UART.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group daplink_if
    ../../../source/daplink/interface/: bootloader_update.c main_interface.c swd_host.c swd_host_ca.c target_flash.c
    ../../../source/daplink/: circ_buf.c cortex_m.c crc32.c daplink_debug.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
  group default
    ../../../source/hic_hal/ingchips/ing91682a/src/StartUP/: __ingsoc.h compiler.h
    ../../../source/hic_hal/ingchips/ing91682a/src/Tools/: ad_parser.h adc_cali.h att_db_util.h audio.h blink.h btstack_mt.h btstack_sync.h freertos_util.h gatt_client_util.h ing_uecc.h log_util.h ota_service.h platform_tools.h platform_util.h port_gen_os.h port_gen_os_driver.h power_ctrl.h rf_util.h ring_buf.h rom_tools.h SEGGER_RTT.h SEGGER_RTT_Conf.h sig_uuid.h str_util.h trace.h uart_driver.h
    ../../../source/hic_hal/ingchips/ing91682a/VenusFTO_Validation_common/registers/: ahbaes_reg.h aon1_ctrl_reg.h aon2_ctrl_reg.h apbspi_reg.h cache_ctrl_reg.h dma_reg.h efuse_reg.h flash_spi_ctrl_reg.h gpio_reg.h i2c_reg.h i2s_reg.h io_mux_ctrl_reg.h ir_reg.h key_scanner_reg.h lle_top_reg.h pdm_reg.h pwm_reg.h qdec_reg.h qspi_reg.h rtc_reg.h sadc_reg.h sys_ctrl_reg.h timer_reg.h trng_reg.h uart_reg.h usbc_reg.h wdt_reg.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h daplink_defaults.h error.h info.h RTE_Components.h util.h validation.h version_git.h
    ../../../source/hic_hal/ingchips/ing91682a/src/BSP/: bsp_usb.h eflash.h
    ../../../source/cmsis-core/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../source/hic_hal/ingchips/ing91682a/VenusFTO_Validation_common/: cm4.h common.h soc.h
    ../../../source/rtos/: cmsis_os2.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/hic_hal/ingchips/ing91682a/src/StartUP/ing916/: compiler.h ingsoc.h
    ../../../source/daplink/cmsis-dap/: DAP.h DAP_queue.h dap_strings.h daplink_vendor_commands.h debug_ca.h debug_cm.h
    ../../../source/hic_hal/ingchips/ing91682a/: DAP_config.h daplink_addr.h ing91682a.h IO_Config.h
    ../../../source/hic_hal/: device.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h uart.h
    ../../../source/hic_hal/cmsis-driver/: Driver_Common.h Driver_USART.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h vfs_user.h virtual_fs.h
    ../../../source/daplink/interface/: main_interface.h swd_host.h tasks.h
    ../../../source/hic_hal/ingchips/ing91682a/src/FWlib/: peripheral_dma.h peripheral_gpio.h peripheral_pinctrl.h peripheral_ssp.h peripheral_sysctrl.h peripheral_timer.h peripheral_uart.h peripheral_usb.h
    ../../../source/usb/: rl_usb.h usb.h usb_bulk.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/daplink/settings/: settings.h
    ../../../source/target/: target_board.h target_config.h target_family.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group family
    ../../../source/family/ingchips/ing916/: target.c
  group hic_hal
    ../../../source/hic_hal/ingchips/ing91682a/src/BSP/: bsp_usb.c eflash.c
    ../../../source/hic_hal/ingchips/ing91682a/: flash.c gpio.c read_uid.c sdk.c uart.c usb_config.c ring_buffer.c
    ../../../source/hic_hal/ingchips/ing91682a/src/FWlib/: peripheral_dma.c peripheral_gpio.c peripheral_pinctrl.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_usb.c
    ../../../source/hic_hal/ingchips/ing91682a/armcc/: startup_ARMCM4.s
  group rtos
    ../../../source/rtos/: cmsis_os2_port.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Config.c
    ../../../source/rtos/cm3/: HAL_CM3.c
    ../../../source/rtos/ARM/: SVC_Table.s
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom.c
  group target
    ../../../source/target/: target_board.c target_default.c target_family.c
  group usb
    ../../../source/usb/bulk/: usbd_bulk.c
    ../../../source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    ../../../source/usb/webusb/: usbd_core_webusb.c
    ../../../source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    ../../../source/daplink/usb2uart/: usbd_user_cdc_acm.c
